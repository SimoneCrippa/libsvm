## Kconfig
```kconfig
config EXTERNAL_LIBSVM
  bool "LIBSVM Library"
  default n
  ---help---
  LIBSVM library providing Support Vector Machines models
  
```
